# Autodesk Inventor part: 본체
## iProperties
Created: 2014-12
Part Number: 본체
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
